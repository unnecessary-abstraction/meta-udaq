FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI += "file://0001-udaq-Updated-platform-muxing-to-expose-the-required-.patch"
